# Keil uVision project RM2016CAMP_INFANTRY.uvprojx, settings and files
target RM2016CAMP_INFANTRY (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RM2016CAMP_INFANTRY
  AfterMake: fromelf.exe  --bin -o ../bin/RM2016CAMP_INFANTRY.bin ./Objects/RM2016CAMP_INFANTRY.axf
  c flags: Optim=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F427_437xx
  c include: ..\app;..\bsp;..\dep;..\imu;..\lib;..\nrf;..\usr;..\alg\crc;..\alg\fifo;..\alg\mafilter;..\alg\pid;..\alg\ramp;..\alg\mecanum;..\alg\sprotocol;C:\Keil_v5\ARM\PACK\ARM\CMSIS\4.5.0\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group alg
    ../alg/crc/: crc8.c crc16.c crc32.c
    ../alg/fifo/: fifo.c
    ../alg/mafilter/: mafilter.c mafilter_f32.c mafilter_i16.c mafilter_i32.c
    ../alg/pid/: pid.c
    ../alg/ramp/: ramp.c
    ../alg/mecanum/: mecanum.c
    ../alg/sprotocol/: sprotocol.c
  group app
    ../app/: Can1Bus.c Can2Bus.c Controller.c InputScaner.c Odometry.c Wireless.c Console.c CanBus.c CanBus.h
  group bsp
    ../bsp/: bsp.c can1.c can2.c chip.c dbus.c delay.c encoder.c led.c motor.c pwm.c QuadEncoder.c spi1.c timer.c usart1.c usart2.c usart3.c zgyro.c
  group imu
    ../imu/: imu.c mpu6050_driver.c mpu6050_i2c.c mpu6050_interrupt.c
  group lib
    ../lib/: misc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c system_stm32f4xx.c startup_stm32f427xx.s
  group nrf
    ../nrf/: NRF24L01.c
  group usr
    ../usr/: main.c
